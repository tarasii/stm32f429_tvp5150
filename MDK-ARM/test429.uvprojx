# Keil uVision project test429.uvprojx, settings and files
target test429 Configuration (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F439IITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: test429 Configuration
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F439xx
  c misc: --C99
  c include: ..\Inc;  ..\Drivers\STM32F4xx_HAL_Driver\Inc;  ..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;  ..\Drivers\CMSIS\Include;  ..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;  ..\Drivers\STM32F4xx_HAL_Driver\Src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Application/User
    ../Src/: ltdc.c usart.c i2c.c fmc.c stm32f4xx_hal_msp.c main.c gpio.c dma.c adc.c dcmi.c stm32f4xx_it.c tvp5150.c svga050.c graph.c dma2d.c itg3200.c 24l64.c adxl345.c hmc5883.c font_7_10.c sdram.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_uart.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_dma.c stm32f4xx_hal_adc.c stm32f4xx_ll_fmc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_dsi.c stm32f4xx_hal_sdram.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_dma2d.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f439xx.s
